## epaper_cli/sdkconfig.defaults
```kconfig
CONFIG_BLINK_LED_GPIO=y
CONFIG_BLINK_GPIO=8
CONFIG_WIFI_SSID="name"
CONFIG_WIFI_PASS="password"
```
